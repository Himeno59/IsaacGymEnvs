Commit message: fix と新しいモデルを追加

File: assets/urdf/board.urdf (robot description, URDF)
Before this commit: robot board, 2 links, 1 joints
Joints:
- joint slider_to_board: limit lower=0 upper=2 effort=1000.0 velocity=10 -> lower=0 upper=1 effort=1000.0 velocity=10
