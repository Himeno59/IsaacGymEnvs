Commit message: fix

File: assets/urdf/objects/ball.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link ball: geometry collision sphere radius=0.1; visual sphere radius=0.1
